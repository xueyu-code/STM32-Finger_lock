# Keil uVision project STM32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\FWlib\inc;.\USER;.\FWlib\src;.\USER\GPIO_Config;.\USER\DELAY;.\USER\EXTI_Config;.\USER\NVIC_Config;.\USER\sys;.\USER\EDP;.\USER\esp8266;.\USER\onenet;.\USER\usart;.\USER\MALLOC;.\USER\esp8266_send;.\USER;.\USER\HC05;.\USER\OLED;.\USER\TIMER;.\USER\USART2;.\USER\AS608;.\USER\KEY;.\USER\BEEP;.\USER\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ./CMSIS/startup/arm/: startup_stm32f10x_md.s
  group USER
    ./USER/: stm32f10x_it.c main.c
    ./USER/DELAY/: delay.c
    ./USER/usart/: usart.c
    ./USER/AS608/: as608.c AS608_use.c
    ./USER/USART2/: usart2.c
    ./USER/TIMER/: timer.c
    ./USER/KEY/: key.c
    ./USER/BEEP/: beep.c
    ./USER/OLED/: oled.c
    ./USER/PWM/: pwm.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
